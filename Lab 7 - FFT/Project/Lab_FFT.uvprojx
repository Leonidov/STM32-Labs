# Keil uVision project Lab_FFT.uvprojx, settings and files
target Lab_FFT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab_FFT
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\RTE;.\STM32F10x_DSP_Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group
    ./: main.c mcu_config.c
  group STM32 DSP Lib
    ./STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_256_stm32.s
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
